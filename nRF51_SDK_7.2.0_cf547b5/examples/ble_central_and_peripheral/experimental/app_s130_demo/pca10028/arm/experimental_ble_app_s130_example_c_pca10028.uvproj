# Keil uVision project experimental_ble_app_s130_example_c_pca10028.uvproj, settings and files
target nrf51422_xxaa_s130 (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxaa_s130 +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 BLE_STACK_SUPPORT_REQD S130 SOFTDEVICE_PRESENT BSP_DEFINES_ONLY BOARD_PCA10028
  c misc: --c99
  c include: ..\..\inc\;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\softdevice\s130\headers;..\..\..\..\..\bsp
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0001C000 size 0x24000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group Application
    ../../src/: main.c rtc1.c uart.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
