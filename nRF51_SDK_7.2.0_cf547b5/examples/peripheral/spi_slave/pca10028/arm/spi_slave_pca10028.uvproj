# Keil uVision project spi_slave_pca10028.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 BOARD_PCA10028
  c misc: --c99
  c include: ..\..\;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\components\libraries\button;..\..\..\..\bsp;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\components\libraries\util
  asm define: NRF51 BOARD_PCA10028
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x39000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c spi_slave_example.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Device
    ../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../components/drivers_nrf/spi_slave/: spi_slave.c
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../components/libraries/timer/: app_timer.c
