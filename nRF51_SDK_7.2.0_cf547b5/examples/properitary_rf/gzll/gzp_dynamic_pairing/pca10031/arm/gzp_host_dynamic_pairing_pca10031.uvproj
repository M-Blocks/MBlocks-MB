# Keil uVision project gzp_host_dynamic_pairing_pca10031.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 BSP_DEFINES_ONLY BOARD_PCA10031
  c misc: --c99
  c include: ..\..\config;..\..\;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\properitary_rf\gzll;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\bsp
  asm define: NRF51 BSP_DEFINES_ONLY BOARD_PCA10031
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x39000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main_host_dynamic_pairing.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: nrf_assert.c
    ../../../../../../components/drivers_nrf/hal/: nrf_ecb.c nrf_nvmc.c
  group nRF_Properiary_RF
    ../../../../../../components/properitary_rf/gzll/arm/: gzll_arm.lib
    ../../../../../../components/properitary_rf/gzll/: nrf_gzp.c nrf_gzp_host.c nrf_gzp_host_nrf51.c
