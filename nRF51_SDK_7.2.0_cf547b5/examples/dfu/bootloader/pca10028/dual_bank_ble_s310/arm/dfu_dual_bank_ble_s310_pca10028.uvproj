# Keil uVision project dfu_dual_bank_ble_s310_pca10028.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD ANT_STACK_SUPPORT_REQD NRF51 BSP_DEFINES_ONLY BOARD_PCA10028 S310 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\components\toolchain;..\..\..\;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\bootloader_dfu\ble_transport;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\hci\config;..\..\..\..\..\..\components\ble\device_manager;..\..\..\..\..\..\components\ble\device_manager\config;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\drivers_nrf\pstorage\config;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\bsp;..\..\..\..\..\..\components\softdevice\s310\headers;..\..\..\..\..\..\components\libraries\bootloader_dfu;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0003C000 size 0x3C00
  memory RVCT9: RAM 0x20002C00 size 0x5380
  memory RVCT10: RAM 0x20007F80 size 0x80
  group Application
    ../../../: dfu_ble_svc.c main.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE_Modules
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/device_manager/: device_manager_peripheral.c
  group nRF_BLE_Services
    ../../../../../../components/ble/ble_services/ble_dfu/: ble_dfu.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/libraries/bootloader_dfu/: bootloader_settings_arm.c bootloader_util_arm.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/bootloader_dfu/: bootloader.c dfu_dual_bank.c dfu_init_template.c dfu_transport_ble.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/hci/: hci_mem_pool.c
    ../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice_Internal
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
