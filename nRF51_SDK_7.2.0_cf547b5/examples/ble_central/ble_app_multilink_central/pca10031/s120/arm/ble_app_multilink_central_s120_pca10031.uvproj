# Keil uVision project ble_app_multilink_central_s120_pca10031.uvproj, settings and files
target nrf51422_xxac_s120 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s120 +hex
  c flags: Optim=4 OneElfS=1
  c define: __HEAP_SIZE=0 NRF51 BSP_DEFINES_ONLY BLE_STACK_SUPPORT_REQD S120 SOFTDEVICE_PRESENT BOARD_PCA10031
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\components\toolchain;..\..\..\;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\..\..\components\softdevice\s120\headers;..\..\..\..\..\bsp;..\..\..\..\..\..\components\ble\device_manager;..\..\..\..\..\..\components\ble\device_manager\config;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\drivers_nrf\pstorage\config;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\util
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x00018000 size 0x27000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group Application
    ../../../: client_handling.c main.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE_Modules
    ../../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../../../../components/ble/common/: ble_srv_common.c
    ../../../../../../components/ble/device_manager/: device_manager_central.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice_Internal
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
