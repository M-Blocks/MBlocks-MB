# Keil uVision project ble_connectivity_s120_hci_pca10028.uvproj, settings and files
target nrf51422_xxac_s120 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s120 +hex
  c flags: Optim=4 OneElfS=1
  c define: __HEAP_SIZE=0 HCI_TIMER2 NRF51 SER_CONNECTIVITY APP_SCHEDULER_WITH_PAUSE BLE_STACK_SUPPORT_REQD S120 SOFTDEVICE_PRESENT BSP_DEFINES_ONLY BOARD_PCA10028
  c misc: --c99
  c include: ..\..\..\..\..\..\components\toolchain;..\..\..\;..\..\..\..\..\..\components\serialization\connectivity\codecs\s120\middleware;..\..\..\..\..\..\components\serialization\connectivity;..\..\..\..\..\..\components\serialization\connectivity\hal;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\serialization\connectivity\codecs\common;..\..\..\..\..\..\components\softdevice\s120\headers;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\serialization\common\transport\ser_phy;..\..\..\..\..\..\components\serialization\common\transport\ser_phy\config;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\bsp;..\..\..\..\..\..\components\serialization\connectivity\codecs\s120\middleware;..\..\..\..\..\..\components\serialization\common\struct_ser\s120;..\..\..\..\..\..\components\serialization\connectivity\codecs\s120\serializers;..\..\..\..\..\..\components\serialization\common\transport;..\..\..\..\..\..\components\serialization\common;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\serialization\application\transport;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x00018000 size 0x27000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group Application
    ../../../: main.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group Modules
    ../../../../../../components/ble/ble_dtm/: ble_dtm.c
  group Serialization
    ../../../../../../components/serialization/connectivity/codecs/common/: ble_dtm_init.c conn_mw.c
    ../../../../../../components/serialization/connectivity/codecs/s120/serializers/: ble_event.c ble_evt_tx_complete.c ble_gap_address_get.c ble_gap_address_set.c ble_gap_adv_data_set.c ble_gap_adv_start.c ble_gap_adv_stop.c ble_gap_appearance_get.c ble_gap_appearance_set.c ble_gap_auth_key_reply.c ble_gap_authenticate.c ble_gap_conn_param_update.c ble_gap_conn_sec_get.c ble_gap_connect.c ble_gap_connect_cancel.c ble_gap_device_name_get.c ble_gap_device_name_set.c ble_gap_disconnect.c ble_gap_encrypt.c ble_gap_evt_adv_report.c ble_gap_evt_auth_key_request.c ble_gap_evt_auth_status.c ble_gap_evt_conn_param_update.c ble_gap_evt_conn_param_update_request.c ble_gap_evt_conn_sec_update.c ble_gap_evt_connected.c ble_gap_evt_disconnected.c ble_gap_evt_passkey_display.c ble_gap_evt_rssi_changed.c ble_gap_evt_sec_info_request.c ble_gap_evt_sec_params_request.c ble_gap_evt_sec_request.c ble_gap_evt_timeout.c ble_gap_ppcp_get.c ble_gap_ppcp_set.c ble_gap_rssi_start.c ble_gap_rssi_stop.c ble_gap_scan_start.c ble_gap_scan_stop.c ble_gap_sec_info_reply.c ble_gap_sec_params_reply.c ble_gap_tx_power_set.c ble_gattc_char_value_by_uuid_read.c ble_gattc_char_values_read.c ble_gattc_characteristics_discover.c ble_gattc_descriptors_discover.c ble_gattc_evt_char_disc_rsp.c ble_gattc_evt_char_val_by_uuid_read_rsp.c ble_gattc_evt_char_vals_read_rsp.c ble_gattc_evt_desc_disc_rsp.c ble_gattc_evt_hvx.c ble_gattc_evt_prim_srvc_disc_rsp.c ble_gattc_evt_read_rsp.c ble_gattc_evt_rel_disc_rsp.c ble_gattc_evt_timeout.c ble_gattc_evt_write_rsp.c ble_gattc_hv_confirm.c ble_gattc_primary_services_discover.c ble_gattc_read.c ble_gattc_relationships_discover.c ble_gattc_write.c ble_gatts_characteristic_add.c ble_gatts_descriptor_add.c ble_gatts_evt_hvc.c ble_gatts_evt_rw_authorize_request.c ble_gatts_evt_sc_confirm.c ble_gatts_evt_sys_attr_missing.c ble_gatts_evt_timeout.c ble_gatts_evt_write.c ble_gatts_hvx.c ble_gatts_include_add.c ble_gatts_rw_authorize_reply.c ble_gatts_service_add.c ble_gatts_service_changed.c ble_gatts_sys_attr_get.c ble_gatts_sys_attr_set.c ble_gatts_value_get.c ble_gatts_value_set.c ble_l2cap_cid_register.c ble_l2cap_cid_unregister.c ble_l2cap_evt_rx.c ble_l2cap_tx.c ble_opt_get.c ble_opt_set.c ble_tx_buffer_count_get.c ble_uuid_decode.c ble_uuid_encode.c ble_uuid_vs_add.c ble_version_get.c conn_ble_gap_sec_keys.c power_system_off.c temp_get.c
    ../../../../../../components/serialization/common/struct_ser/s120/: ble_gap_struct_serialization.c ble_gattc_struct_serialization.c ble_gatts_struct_serialization.c ble_struct_serialization.c
    ../../../../../../components/serialization/common/: ble_serialization.c cond_field_serialization.c
    ../../../../../../components/serialization/connectivity/codecs/s120/middleware/: conn_mw_ble.c conn_mw_ble_gap.c conn_mw_ble_gattc.c conn_mw_ble_gatts.c conn_mw_ble_l2cap.c conn_mw_nrf_soc.c
    ../../../../../../components/serialization/connectivity/hal/: dtm_uart.c
    ../../../../../../components/serialization/connectivity/: ser_conn_cmd_decoder.c ser_conn_dtm_cmd_decoder.c ser_conn_error_handling.c ser_conn_event_encoder.c ser_conn_handlers.c ser_conn_pkt_decoder.c
    ../../../../../../components/serialization/common/transport/: ser_hal_transport.c
    ../../../../../../components/serialization/common/transport/ser_phy/: ser_phy_hci.c ser_phy_hci_slip.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../../components/serialization/application/transport/: app_mailbox.c
    ../../../../../../components/libraries/scheduler/: app_scheduler_serconn.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/crc16/: crc16.c
  group nRF_SoftDevice_Internal
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
