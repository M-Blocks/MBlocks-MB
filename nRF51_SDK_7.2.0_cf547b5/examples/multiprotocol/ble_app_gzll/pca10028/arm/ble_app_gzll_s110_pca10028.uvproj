# Keil uVision project ble_app_gzll_s110_pca10028.uvproj, settings and files
target nrf51422_xxac_s110 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BOARD_PCA10028
  c misc: --c99
  c include: ..\..\..\..\..\components\toolchain;..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\bsp;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\components\properitary_rf\gzll;..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\components\ble\common;..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\components\libraries\button;..\..\..\..\..\components\libraries\timer;..\..\..\..\bsp;..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\components\libraries\util
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x00016000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../: ble_app_gzll_device.c ble_app_gzll_hr.c ble_app_gzll_ui.c main.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Device
    ../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_BLE_Modules
    ../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_BLE_Services
    ../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../components/ble/ble_services/ble_hrs/: ble_hrs.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../components/drivers_nrf/hal/: nrf_delay.c
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../components/libraries/timer/: app_timer_ble_gzll.c
    ../../../../../components/libraries/sensorsim/: ble_sensorsim.c
  group nRF_Properiary_RF
    ../../../../../components/properitary_rf/gzll/arm/: gzll_arm.lib
  group nRF_SoftDevice_Internal
    ../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
