# Keil uVision project ant_sdm_tx_s210_pca10028.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: TRACE_GPIO TRACE_UART NRF51 BSP_DEFINES_ONLY ANT_STACK_SUPPORT_REQD S210 SOFTDEVICE_PRESENT BOARD_PCA10028
  c misc: --c99
  c include: ..\..\include;..\..\..\..\..\..\components\toolchain;..\..\;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\softdevice\s210\headers;..\..\..\..\..\bsp;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0000D000 size 0x33000
  memory RVCT9: RAM 0x20000900 size 0x7700
  group Application
    ../../: main.c retarget.c sdm_tx.c timer.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/gpiote/: app_gpiote.c
