# Keil uVision project ant_bicycle_power_minimum_receiver_s310_pca10028.uvproj, settings and files
target nrf51422_xxac_s310 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s310 +hex
  c flags: Optim=4 OneElfS=1
  c define: TRACE_UART TRACE_CALIBRATION TRACE_DATA_PAGE ANT_STACK_SUPPORT_REQD BLE_STACK_SUPPORT_REQD NRF51 S310 SOFTDEVICE_PRESENT BOARD_PCA10028
  c misc: --c99
  c include: ..\..\..\include;..\..\..\..\..\..\..\components\toolchain;..\..\..\;..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\softdevice\s310\headers;..\..\..\..\..\..\bsp;..\..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\util
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0001D000 size 0x22000
  memory RVCT9: RAM 0x20002400 size 0x5C00
  group Application
    ../../../: bicycle_power_rx.c main.c main_bicycle_power_rx.c retarget.c
  group Board Support
    ../../../../../../bsp/: bsp.c
  group Device
    ../../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../../components/drivers_nrf/hal/: nrf_delay.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer.c
